# Keil uVision project A65.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC51P0304 silan
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(500000) MODP2
  output: TX-88 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\src
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./src/: init.c interrupt.c process.c key.c PowerUp.c hdmidet.c
